# Keil uVision project H7_Base.uvprojx, settings and files
target H7_Base (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: H7_Base +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../CubotMiddleware;../CubotMiddleware/Algorithms;../CubotMiddleware/Devices;../CubotMiddleware/Drivers;../CubotMiddleware/Modules;../CubotMiddleware/Support;../User;../MIddlewaves/ARM/DSP/Include;../MIddlewaves/ARM/DSP/Include/dsp;..\MIddlewaves\ARM\DSP\Source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c fdcan.c i2c.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Cubot/Drivers
    ../CubotMiddleware/Drivers/: driver_can.c driver_usart.c driver_timer.c driver_counter.c driver_iic.c driver_spi.c
  group Cubot/User
    ../User/: control_logic.c hardware_config.c
  group Cubot/Modules
    ../CubotMiddleware/Modules/: shoot.c swerve_chassis.c holder.c communication.c interboard.c
    ../CubotMiddleware/Devices/: check.c
  group Cubot/Devices
    ../CubotMiddleware/Devices/: dr16.c et08.c motor.c mpu6050.c bmi088.c referee.c Supercap.c DM_motor.c LK_motor.c
  group Cubot/Algorithms
    ../CubotMiddleware/Algorithms/: filter.c kalman.c kalman_filter.c pid.c quaternions_EKF.c user_lib.c
    ../CubotMiddleware/Modules/: ins.c
  group MIddlewaves
    ../MIddlewaves/ARM/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../MIddlewaves/ARM/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../MIddlewaves/ARM/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../MIddlewaves/ARM/DSP/Source/CommonTables/: CommonTables.c
    ../MIddlewaves/ARM/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
software components: CMSIS:CORE 4.3.0
